File: DC_MOTOR_0.1.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: Export
Parts:
- gave numbers to parts that had none: 12
